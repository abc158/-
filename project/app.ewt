<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>src</name>
    <group>
      <name>cfg</name>
      <file>
        <name>$PROJ_DIR$\..\src\cfg\afio_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cfg\exti_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cfg\gpio_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cfg\spi_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cfg\tm_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\cfg\uart_cfg.c</name>
      </file>
    </group>
    <group>
      <name>charge</name>
      <file>
        <name>$PROJ_DIR$\..\src\charge\charge.c</name>
      </file>
    </group>
    <group>
      <name>diagnostics</name>
      <file>
        <name>$PROJ_DIR$\..\src\motor\hardward_check.c</name>
      </file>
    </group>
    <group>
      <name>dock</name>
      <file>
        <name>$PROJ_DIR$\..\src\dock\docking-new.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\dock\docking-sensors.c</name>
      </file>
    </group>
    <group>
      <name>guardrail</name>
      <file>
        <name>$PROJ_DIR$\..\src\guardrail\dock-avoid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\guardrail\virtual-wall.c</name>
      </file>
    </group>
    <group>
      <name>local_process</name>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\act.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\display.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\led_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\local_key_check.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\local_process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\local_process\remote.c</name>
      </file>
    </group>
    <group>
      <name>motor</name>
      <file>
        <name>$PROJ_DIR$\..\src\motor\motor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\motor\robot_brush.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\motor\robot_suction.c</name>
      </file>
    </group>
    <group>
      <name>sensor</name>
      <file>
        <name>$PROJ_DIR$\..\src\sensor\lt_bump.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\monitor\robot_univrsal_wheel.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\sensor\sensor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\sensor\sensor_comm.c</name>
      </file>
    </group>
    <group>
      <name>ui-manager</name>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\exception.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\ir_decode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\remote_handle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\monitor\robot-battery-monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\monitor\robot_battery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\song-player.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\test_cmd_handle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\ui-config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\ui-manager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\ui-manager\ui-msg-handler.c</name>
      </file>
    </group>
    <group>
      <name>ui_uart_handle</name>
      <file>
        <name>$PROJ_DIR$\..\src\ui_uart_handle\uart_queue.c</name>
      </file>
    </group>
    <group>
      <name>util</name>
      <file>
        <name>$PROJ_DIR$\..\src\util\current.c</name>
      </file>
    </group>
    <group>
      <name>wall_follow</name>
      <file>
        <name>$PROJ_DIR$\..\src\wall_follow\wall_follow_common.c</name>
      </file>
    </group>
    <group>
      <name>wifi</name>
      <group>
        <name>wifi_demo1</name>
        <file>
          <name>$PROJ_DIR$\..\src\wifi\wifi_demo1\SimSweep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\wifi\wifi_demo1\SimWifi.c</name>
        </file>
      </group>
      <group>
        <name>wifi_demo2</name>
        <file>
          <name>$PROJ_DIR$\..\src\wifi\wifi_demo2\SimSweep_demo2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\src\wifi\wifi_demo2\simwifi_demo2.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\src\wifi\uart_wifi_check.c</name>
      </file>
    </group>
    <group>
      <name>wireless</name>
      <file>
        <name>$PROJ_DIR$\..\src\wireless\ARF2496K.C</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
    </file>
  </group>
</project>


