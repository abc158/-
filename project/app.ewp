# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.PreInclude: ..\lib\syscall_api.h
  ICCARM.CCIncludePath2: ..\includes; ..\src\includes; ..\lib; ..\src\; ..\src\local_process; ..\src\cfg; ..\src\dock; ..\src\guardrail
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.s19
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: Amicro_R10_flash_release.icf
  ILINK.IlinkAdditionalLibs: startup\startup.a; ..\lib\syscall_api.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\inc; ..\include; ..\src\includes; ..\lib; ..\src\local_process
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkAdditionalLibs: C:\Users\luenwan\Documents\eSlamNXForSDK\floor-care\app_project\project\startup\startup.a
  group src
    ../src/: main.c
  group src/cfg
    ../src/cfg/: afio_cfg.c exti_cfg.c gpio_cfg.c spi_cfg.c tm_cfg.c uart_cfg.c
  group src/charge
    ../src/charge/: charge.c
  group src/diagnostics
    ../src/motor/: hardward_check.c
  group src/dock
    ../src/dock/: am-docking-config.c am-docking-new.c am-docking-sensors.c am-docking-utils.c dock_ir_signal.c docking-new.c docking-sensors.c
  group src/guardrail
    ../src/guardrail/: dock-avoid.c virtual-wall.c
  group src/local_process
    ../src/local_process/: act.c display.c led_drv.c lib.c local_key_check.c local_process.c remote.c
  group src/motor
    ../src/motor/: motor.c robot_brush.c robot_suction.c
  group src/sensor
    ../src/sensor/: lt_bump.c sensor.c sensor_comm.c
    ../src/monitor/: robot_univrsal_wheel.c
  group src/ui-manager
    ../src/ui-manager/: exception.c ir_decode.c remote_handle.c song-player.c test_cmd_handle.c ui-config.c ui-manager.c ui-msg-handler.c
    ../src/monitor/: robot-battery-monitor.c robot_battery.c
  group src/ui_uart_handle
    ../src/ui_uart_handle/: uart_queue.c
  group src/util
    ../src/util/: current.c
  group src/wall_follow
    ../src/wall_follow/: wall_follow_common.c
  group src/wifi
    ../src/wifi/: uart_wifi_check.c
  group src/wifi/wifi_demo1
    ../src/wifi/wifi_demo1/: SimSweep.c SimWifi.c
  group src/wifi/wifi_demo2
    ../src/wifi/wifi_demo2/: SimSweep_demo2.c simwifi_demo2.c
  group src/wireless
    ../src/wireless/: ARF2496K.C
